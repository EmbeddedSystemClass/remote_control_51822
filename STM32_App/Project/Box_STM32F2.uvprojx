# Keil uVision project Box_STM32F2.uvprojx, settings and files
target Box_STM32F2 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F207ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: MultiBox_STM32F2 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx,SYN_DEBUG
  c misc: --C99
  c include: ..\Inc;..\Drivers\STM32F2xx_HAL_Driver\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F2xx\Include;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\Middlewares;..\Drivers;..\Middlewares\Third_Party\FatFs\src;..\Src;..\Middlewares\FilesSys;..\Middlewares\FreeRTOS\Source\CMSIS_RTOS;..\Middlewares\FreeRTOS\Source\include;..\Drivers\BSP;..\Middlewares\Source;..\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\Drivers\Driver;..\Middlewares\Third_Party\lobaro-coap;..\Middlewares\Third_Party\lobaro-coap\interface\network;..\Middlewares\Third_Party\lobaro-coap\interface
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0xf8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: apl_watchdog.c stm32f2xx_hal_msp.c apl_cli.c main.c stm32f2xx_it.c apl_key.c apl_service.c apl_ble.c apl_bat.c apl_monitor_template.c
    ../Inc/: includes.h
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f207xx.s
  group Middlewares
    ../Middlewares/Source/: DataConvert.c user_diskio.c ymodem.c CLI_CmdFile.c mid_CLI.c mid_net.c ble_communication.c crc16.c
    ../Src/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group Drivers
    ../Drivers/Driver/: drv_CmuUart.c drv_SpiCmu.c drv_FlashSpi.c drv_led.c drv_CdmaUart.c drv_cdma.c drv_rtc.c drv_sys.c drv_Spi2.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_ll_fsmc.c stm32f2xx_hal_pwr.c stm32f2xx_hal_gpio.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal.c stm32f2xx_hal_uart.c stm32f2xx_hal_spi.c stm32f2xx_hal_flash.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_i2c.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_dma.c stm32f2xx_hal_sram.c stm32f2xx_hal_rcc.c stm32f2xx_hal_cortex.c stm32f2xx_hal_eth.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_can.c stm32f2xx_hal_tim.c stm32f2xx_hal_adc.c stm32f2xx_hal_dac.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_dac_ex.c stm32f2xx_hal_usart.c stm32f2xx_hal_iwdg.c stm32f2xx_hal_rtc_ex.c stm32f2xx_hal_rtc.c stm32f2xx_hal_rng.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/CoAP
    ../Middlewares/Third_Party/lobaro-coap/: coap_interaction.c coap_main.c coap_message.c coap_options.c coap_resource.c lobaro-coap_esp8266.c
    ../Middlewares/Third_Party/lobaro-coap/option-types/: coap_option_blockwise.c coap_option_cf.c coap_option_ETag.c coap_option_observe.c coap_option_uri.c
    ../Middlewares/Third_Party/lobaro-coap/interface/debug/: coap_debug.c
    ../Middlewares/Third_Party/lobaro-coap/interface/mem/: coap_mem.c
    ../Middlewares/Third_Party/lobaro-coap/interface/network/: net_Endpoint.c net_Packet.c net_Socket.c
