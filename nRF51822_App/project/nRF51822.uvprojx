# Keil uVision project nRF51822.uvprojx, settings and files
target nRF51822 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nRF51822 +hex
  AfterMake: find "Total R" ./Listing/nRF51822.map
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD __STACK_SIZE=2048 __HEAP_SIZE=1024 NRF51422 BOARD_PCA10028 S130 NRF_SD_BLE_API_VERSION=2 NRF51 SOFTDEVICE_PRESENT FREERTOS
  c include: ..\source\Application;..\source\BSP;..\source\Drivers\CMSIS;..\source\Middlewares\freertos;..\source\Middlewares\freertos\source\include;..\source\Middlewares\freertos\portable\ARM\nrf51;..\source\Middlewares\freertos\portable\CMSIS\nrf51;..\source\SDK1210\softdevice\common\softdevice_handler;..\source\SDK1210\softdevice\s130\headers;..\source\SDK1210\libraries\util;..\source\SDK1210\drivers_nrf\hal;..\source\SDK1210\drivers_nrf\clock;..\source\SDK1210\drivers_nrf\common;..\source\SDK1210\libraries\log;..\source\SDK1210\libraries\log\src;..\source\SDK1210\libraries\uart;..\source\SDK1210\libraries\fifo;..\source\SDK1210\libraries;..\source\SDK1210\drivers_nrf;..\source\SDK1210\drivers_nrf\uart;..\source\nRF_BLE\ble_advertising;..\source\nRF_BLE\ble_db_discovery;..\source\nRF_BLE\common;..\source\SDK1210\libraries\fstorage;..\source\SDK1210\libraries\experimental_section_vars;..\source\SDK1210\libraries\timer;..\source\nRF_BLE\ble_central_manage;..\source\nRF_BLE\ble_peripheral_services;..\source\Shell;..\source\SDK1210\drivers_nrf\timer;..\source\Middlewares\scheduler;..\source\SDK1210\softdevice\common\softdevice_handler;..\source\nRF_BLE\ble_central_services;..\source\SDK1210\drivers_nrf\delay;..\source\SDK1210\drivers_nrf\spi_slave
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-D__STACK_SIZE=2048,-D__HEAP_SIZE=1024,-DNRF51422,-DBOARD_PCA10028,-DS130,-DNRF_SD_BLE_API_VERSION=2,-DNRF51,-DSOFTDEVICE_PRESENT,-DFREERTOS
  asm include: ..\source\SDK1210\toolchain
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x25000
  memory RVCT9: RAM 0x20003000 size 0x5000
  group Application
    ../source/Application/: main.c platform.h ble_top_implementation.c system_info_test.c app_device_manage.c app_data_sync.c app_cmu_manage.c
    ../source/SDK1210/libraries/hardfault/nrf51/handler/: hardfault_handler_keil.c
    ../source/SDK1210/libraries/hardfault/: hardfault_implementation.c
  group bsp
    ../source/BSP/: bsp.c bsp_uart.c bsp_led.c bsp_spis.c
  group Drivers
    ../source/SDK1210/drivers_nrf/clock/: nrf_drv_clock.c
    ../source/SDK1210/drivers_nrf/common/: nrf_drv_common.c
    ../source/SDK1210/drivers_nrf/uart/: nrf_drv_uart.c
    ../source/SDK1210/drivers_nrf/timer/: nrf_drv_timer.c
    ../source/SDK1210/drivers_nrf/spi_slave/: nrf_drv_spis.c
  group nRF_BLE
    ../source/nRF_BLE/ble_advertising/: ble_advertising.c
    ../source/nRF_BLE/ble_db_discovery/: ble_db_discovery.c
    ../source/nRF_BLE/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../source/nRF_BLE/ble_central_manage/: ble_central_manage.c
    ../source/nRF_BLE/ble_central_services/: ble_central_service_bonding.c ble_central_service_devinfo_manage.c ble_central_service_monitor_template.c ble_central_service_sync_data.c
  group Middleware/Scheduler
    ../source/Middlewares/scheduler/: app_scheduler.c
    ../source/SDK1210/softdevice/common/softdevice_handler/: softdevice_handler_appsh.c
  group Middleware/Shell
    ../source/Shell/: shell.c ble_shell.c
  group SDK/Sofedevice
    ../source/SDK1210/softdevice/common/softdevice_handler/: softdevice_handler.c
  group SDK/Libraries
    ../source/SDK1210/libraries/util/: app_util_platform.c app_error.c app_error_weak.c nrf_assert.c sdk_mapped_flags.c
    ../source/SDK1210/libraries/uart/: app_uart_fifo.c retarget.c
    ../source/SDK1210/libraries/fifo/: app_fifo.c
    ../source/SDK1210/libraries/fstorage/: fstorage.c
    ../source/SDK1210/libraries/timer/: app_timer_appsh.c app_timer.c
  group Documentation
    ../source/Doc/: readMe.txt
software components: CMSIS:CORE 4.3.0, Device:Startup 8.9.0
