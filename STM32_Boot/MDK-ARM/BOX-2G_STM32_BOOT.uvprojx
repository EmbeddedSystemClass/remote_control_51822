# Keil uVision project BOX-2G_STM32_BOOT.uvprojx, settings and files
target BOX-2G (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F207ZG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: BOX-2G_STM32_BOOT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F207xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F2xx_HAL_Driver/Inc;../Drivers/STM32F2xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F2xx/Include;..\Drivers\Drv
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f2xx_hal_msp.c main.c stm32f2xx_it.c CRC.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group Application/MDK-ARM
    ./: startup_stm32f207xx.s
  group Drivers/STM32F2xx_HAL_Driver
    ../Drivers/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_flash.c stm32f2xx_hal_tim.c stm32f2xx_hal_pwr.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_uart.c stm32f2xx_hal_dma.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal.c stm32f2xx_hal_gpio.c stm32f2xx_hal_dma_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_spi.c stm32f2xx_hal_usart.c
  group Drivers/Drv
    ../Drivers/Drv/: drv_FlashSpi.c MX25L1606E.c
software components: CMSIS:CORE 4.3.0
